# Keil uVision project USBH_MSC.uvproj, settings and files
target 神舟王STM322xG-EVAL_USBH-FS (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL_FS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\DFU;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\DFU\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\..\Utilities\slef;..\..\..\..\Utilities\uCOS-II\Ports;..\..\..\..\Utilities\uCOS-II
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM322xG-EVAL\STM322xG-EVAL_FS.sct
  group App
    ../src/: stm32fxxx_it.c usb_bsp.c main.c usbh_usr.c app_task.c
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
  group USB Host
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
  group FAT FS
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c fattime.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F2xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_usart.c stm32f2xx_tim.c stm32f2xx_sdio.c
  group STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_sdio_sd.c stm322xg_eval.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c
    ../../../../Utilities/STM32_EVAL/Common/: xprintf.c
  group Doc
    ../: readme.txt
  group USB_Host_HID
    ../../../../../USB_U_DFU/Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c
    ../../../../Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_mouse.c
  group USB_Host_DFU
    ../../../../Libraries/STM32_USB_HOST_Library/Class/DFU/src/: usbh_dfu_core.c
  group slef
    ../../../../Utilities/slef/: UART.C lib.c timer.c rtc.c shell.c
  group Ucosii\Src
    ../../../../Utilities/uCOS-II/Source/: os_core.c os_mbox.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ucosii\Ports
    ../../../../Utilities/uCOS-II/Ports/: os_dbg.c os_cpu_c.c os_cpu_a.asm
